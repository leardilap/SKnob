# IAR project SKnob.ewp, settings and files
configuration SKnob (ARM, debug)
  General.OGChipSelectEditMenu: STM32WB55CC ST STM32WB55CC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 6
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32WB55xx
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32WBxx_HAL_Driver/Inc; ../Drivers/STM32WBxx_HAL_Driver/Inc/Legacy; ../Middlewares/Third_Party/FreeRTOS/Source/include; ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2; ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F; ../Middlewares/ST/STM32_USB_Device_Library/Core/Inc; ../Middlewares/ST/STM32_USB_Device_Library/Class/CustomHID/Inc; ../Drivers/CMSIS/Device/ST/STM32WBxx/Include; ../Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ../Inc
  OBJCOPY.OOCOutputFile: SKnob.hex
  ILINK.IlinkOutputFile: SKnob.out
  ILINK.IlinkIcfFile: stm32wb55xx_flash_cm4.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32wb55xx_cm4.s
  group Application/User
    ../Src/: main.c app_freertos.c usb_device.c usbd_conf.c usbd_desc.c usbd_custom_hid_if.c stm32wbxx_it.c stm32wbxx_hal_msp.c stm32wbxx_hal_timebase_tim.c
  group Drivers/STM32WBxx_HAL_Driver
    ../Drivers/STM32WBxx_HAL_Driver/Src/: stm32wbxx_hal_gpio.c stm32wbxx_hal_pcd.c stm32wbxx_hal_pcd_ex.c stm32wbxx_ll_usb.c stm32wbxx_hal_rcc.c stm32wbxx_hal_rcc_ex.c stm32wbxx_hal_flash.c stm32wbxx_hal_flash_ex.c stm32wbxx_hal_hsem.c stm32wbxx_hal_dma.c stm32wbxx_hal_dma_ex.c stm32wbxx_hal_pwr.c stm32wbxx_hal_pwr_ex.c stm32wbxx_hal_cortex.c stm32wbxx_hal.c stm32wbxx_hal_exti.c stm32wbxx_hal_adc.c stm32wbxx_hal_adc_ex.c stm32wbxx_ll_adc.c stm32wbxx_hal_i2c.c stm32wbxx_hal_i2c_ex.c stm32wbxx_hal_tim.c stm32wbxx_hal_tim_ex.c stm32wbxx_hal_uart.c stm32wbxx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32wbxx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CustomHID/Src/: usbd_customhid.c
